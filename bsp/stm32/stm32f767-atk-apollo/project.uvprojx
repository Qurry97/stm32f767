# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F767xx, USE_HAL_DRIVER, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c include: applications;.;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m7;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;board;board\CubeMX_Config\Inc;board\ports;..\libraries\HAL_Drivers;..\libraries\HAL_Drivers\config;..\..\..\components\finsh;.;..\..\..\include;..\..\..\components\libc\compilers\common;..\..\..\components\libc\compilers\common\none-gcc;..\libraries\STM32F7xx_HAL\STM32F7xx_HAL_Driver\Inc;..\libraries\STM32F7xx_HAL\CMSIS\Device\ST\STM32F7xx\Include;..\libraries\STM32F7xx_HAL\CMSIS\Include;..\..\..\examples\utest\testcases\kernel
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group CPU
    ../../../libcpu/arm/common/: div0.c backtrace.c showmem.c
    ../../../libcpu/arm/cortex-m7/: cpuport.c context_rvds.S cpu_cache.c
  group DeviceDrivers
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: waitqueue.c ringblk_buf.c ringbuffer.c completion.c pipe.c dataqueue.c workqueue.c
  group Drivers
    board/CubeMX_Config/Src/: stm32f7xx_hal_msp.c
    ../libraries/STM32F7xx_HAL/CMSIS/Device/ST/STM32F7xx/Source/Templates/arm/: startup_stm32f767xx.s
    board/: board.c
    ../libraries/HAL_Drivers/: drv_sdram.c drv_gpio.c drv_usart.c drv_lcd.c drv_common.c
  group finsh
    ../../../components/finsh/: shell.c cmd.c msh.c
  group Kernel
    ../../../src/: kservice.c ipc.c mempool.c clock.c thread.c object.c scheduler.c irq.c memheap.c timer.c components.c device.c idle.c
  group libc
    ../../../components/libc/compilers/common/: time.c
  group Libraries
    ../libraries/STM32F7xx_HAL/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_uart_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_sram.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_crc.c stm32f7xx_hal_usart.c stm32f7xx_hal_rcc.c stm32f7xx_hal_cec.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_gpio.c stm32f7xx_ll_dma2d.c stm32f7xx_hal_exti.c stm32f7xx_ll_fmc.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_dma.c stm32f7xx_hal_uart.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_crc_ex.c
    ../libraries/STM32F7xx_HAL/CMSIS/Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
